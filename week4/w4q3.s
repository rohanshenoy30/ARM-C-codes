	AREA RESET, DATA, READONLY
	EXPORT __Vectors

__Vectors
	DCD 0x40001000
	DCD Reset_Handler
	ALIGN
	AREA mycode, CODE, READONLY
	ENTRY
	EXPORT Reset_Handler
Reset_Handler
	LDR R0, =SRC
	LDR R1, =DST
	LDR R2, [R0]
	
DIV
	MOV R3, #0
	
COMP
	CMP R2, #10
	BCC STORE
	SUB R2, #10
	ADD R3, #1
	B COMP
STORE
	STRB R2, [R1], #1
	CMP R3, #0
	BEQ PACK
	MOV R2, R3
	B DIV
PACK
	LDR R0, =DST
	LDR R1, =PACKED
	LDRB R2, [R0, #1]
	LSL R2, #4
	LDRB R3, [R0]
	ADD R2, R3
	STRB R2, [R1], #1
	ADD R0, #2
	LDRB R2, [R0, #1]
	LSL R2, #4
	LDRB R3, [R0]
	ADD R2, R3
	STRB R2, [R1]
STOP B STOP
SRC DCD 0x0119
	AREA data, DATA, READWRITE
DST DCD 0
PACKED DCD 0
END